# Keil uVision project stm32f103c8_si4463.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103c8_si4463_device +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\CORE;.\HEADWARE\inc;.\STM32F10x_FWLib\inc;..\gengxinxieyiban;.\CORE\startup
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ./: main.cpp
  group HEADWARE
    ./HEADWARE/src/: drv_delay.c drv_led.c drv_spi.c drv_uart.c key.c data_process.cpp drv_button.cpp drv_SI4463.cpp stm32_flash.c
  group FWLIB
    ./STM32F10x_FWLib/src/: misc.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_flash.c
  group CORE
    ./CORE/: core_cm3.c
    ./CORE/startup/: startup_stm32f10x_md.s
